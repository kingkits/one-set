# Keil uVision project vent_new.uvprojx, settings and files
target linux_share (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F439BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: linux_share +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F439xx,ARM_MATH_CM4, __CC_ARM
  c misc: --C99
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;                                       ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                       ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                       ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                       ../Middlewares/Third_Party/FreeRTOS/Source/include;                                       ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                       ../Drivers/CMSIS/Include;   ../Core/Inc
  asm include: ..\Inc;..\\Inc;..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: vent_new\vent_new.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f439xx.s
  group Application/User
    ../Src/comunication/: uart_manager.c lcd_manager.c
    ../Src/: global.c sdram.c main_task.c timer.c reset.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Application/User/adc
    ../Src/adc/: adc_manager.c flow_sensor_840205.c flow_sensor.c Calibration.c ADC_data_solution.c
  group Application/User/spi
    ../Src/spi/: spi.c fm25v05.c
  group Application/User/interface
    ../Src/user_interface/: kbd.c
  group Application/User/cmd_line
    ../Src/cmd_line/: cmd_line.c
  group UI_interface
    ../Src/comunication/: UI_data.c
  group Application/User/PWM
    ../Src/Blower/: Blower.c
    ../Src/VoiceCoilMotor/: Voice_Coil_Motor.c
  group data_manager
    ../lib/Objects/: lib_data.lib
  group test
    ../Src/test/: pwm_test.c leak_test.c peep_test.c
    ../Src/: test.c
  group Application/User/GPIO
    ../Src/GPIO/: gpio.c
  group OxygenMixer
    ../Src/OxygenMixer/: OxygenMixter.c
  group ControlTask
    ../Src/ControlTask/: Control_Task.c base_control.c Breath_Control_Task.c
  group ModeControl
    ../Src/ModeControl/: breath_Atomizer.c breath_control.c breath_cough.c breath_monitor.c breath_rap.c breath_rap_dma_control.c breath_cycle_adjust.c Display_data_count.c pcv_control.c pcv_press_increase_data.c trigger_breath.c cpap_control.c rap_control.c st_control.c
  group Alarm
    ../Src/alarm/: alarm.c
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/Lib
    ../Core/lib/: VentlatorLIB.lib
  group Calibration
    ../Src/calibration/: flow_sensor_simple_calibration.c
software components: CMSIS:CORE 5.1.2
